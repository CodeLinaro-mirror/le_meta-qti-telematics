FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://add-660-permissions-to-the-leprop-service-socket.patch"
